Commit message: Fixed bugs.

File: launch/obstacle.urdf (robot description, URDF)
Before this commit: robot obstacle, 1 links, 0 joints
Links:
- link my_obstacle: mass 1.0 -> 10.0; geometry collision box size=1 1 2; visual cylinder length=7 radius=0.1
